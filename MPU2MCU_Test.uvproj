# Keil uVision project MPU2MCU_Test.uvproj, settings and files
target Target 1 (MCS-51)
  device: T89C51AC2 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF) XRAM (0-0x3FF) CLOCK(40000000) MODP2
  output: MPU2MCU_Test +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 MPU2MCU_Test.c
