

void main(){
	unsigned char code O_Value[length]={0xc3,0xbd,0xbd,0xbd,0xc3,0xff,0xff,0xff,0xff,0xff,0xff,0Xff};
	unsigned char code T_Value[length]={0xfc,0x7e,0x00,0x7e,0xfc,0xff,0xff,0xff,0xff,0xff,0xff,0Xff};
	unsigned char code P_Value[length]={0xf1,0xee,0xee,0x6e,0x00,0x7e,0xff,0xff,0xff,0xff,0xff,0Xff};
	unsigned char code OPT_Value[36]={0xc3,0xbd,0xbd,0xbd,0xc3,0xff,0xff,0xff,0xff,0Xff,0xff,0xff,0xf1,0xee,0xee,0x6e,0x00,0x7e,0xff,0xff,0xff,0xff,0xff,0Xff,0xfc,0x7e,0x00,0x7e,0xfc,0xff,0xff,0xff,0xff,0xff,0xff,0Xff};
	int S_P_1=0,S_P_2=0,S_P_3=0;
		if(AngleNew>0&&AngleNew<120){
			S_P_2=0;
			S_P_3=0;
			if(S_P_1<length){
			P0=O_Value[S_P_1];
			//P1=P_Value[S_P_1];
			//P2=T_Value[S_P_1];
			S_P_1++;
			delay_50us(5);
			}

		}
		else if(AngleNew>120&&AngleNew<240){
				S_P_1=0;
				S_P_3=0;
			if(S_P_2<length){
				P1=O_Value[S_P_2];
				P2=P_Value[S_P_2];
				P0=T_Value[S_P_2];
				S_P_2++;
			delay_50us(5);
			}

		}
		else if(AngleNew>225&&AngleNew<345){
			S_P_1=0;
			S_P_2=0;
			if(S_P_3<length){
				P2=O_Value[S_P_3];
				P1=T_Value[S_P_3];
				P0=P_Value[S_P_3];
				S_P_3++;
				delay_50us(5);
			}

		}
		else{
		P0=0xff;
		P1=0xff;
		P2=0xff;
		}
}